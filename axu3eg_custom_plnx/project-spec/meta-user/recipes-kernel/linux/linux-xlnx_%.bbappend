SRC_URI += "file://user_2021-07-23-19-06-00.cfg"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

